## drivers/input/touchscreen/ilitek_0flash_mmi/Kconfig
```kconfig
config TOUCHSCREEN_ILITEK_0FLASH_MMI
	tristate "Motorola ILITEK zero-flash touchscreen"
	depends on SPI
```
